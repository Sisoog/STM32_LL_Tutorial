# Keil uVision project Wave Player.uvprojx, settings and files
target Wave Player (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Wave Player +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32F103xE,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Core\fatfs;..\Core\wavePlayer;..\Core\NokiaTFTLib;..\Core\waveplayer_LCD_Utility
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: stdio_usart1.c main.c stm32f1xx_it.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_gpio.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_ll_spi.c stm32f1xx_ll_pwr.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group fatfs
    ../Core/fatfs/: ff.c ffsystem.c ffunicode.c mmc_stm32f1_spi.c
  group wave_player
    ../Core/wavePlayer/: SD_Utility.c WAV_Handler.c
  group Nokia TFT
    ../Core/NokiaTFTLib/: nokia1661_lcd_driver.c
  group waveplayer_LCD_Utility
    ../Core/waveplayer_LCD_Utility/: waveplayer_LCD_Utility.c
software components: CMSIS:CORE 5.5.0, Compiler:I/O:STDOUT 1.2.0
